# IAR project nshell_twrkw24d512kw21.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/include; ../../../source/include; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../../../platform/startup; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/CMSIS/Include; ../../../../config/mcu/mkw24d512kw21; ../../../../config/board/twrkw24d512kw21; ../../../../../../boards/twrkw24d512kw21; ../../../../../../platform/startup/MKW21D5; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/nio; ../../../../mqx/source/nio/src; ../../../../mqx/source/nio/fs; ../../../../mqx/source/nio/drivers/nio_dummy; ../../../../mqx/source/nio/drivers/nio_mem; ../../../../mqx/source/nio/drivers/nio_null; ../../../../mqx/source/nio/drivers/nio_pipe; ../../../../mqx/source/nio/drivers/nio_serial; ../../../../mqx/source/nio/drivers/nio_tfs; ../../../../mqx/source/nio/drivers/nio_tty; ../../../../mqx/source/tad; ../../../../mqx/source/include; ../../../../mqx_stdlib/source/include; ../../../../mqx_stdlib/source/stdio; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/utilities/inc; ../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../..; ../../../../../../platform/osa/inc; ../../../../../../platform/system/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; _DEBUG=1
  AARM.AUserIncludes: ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m; ../../../../../../platform/startup; ../../../../config/mcu/mkw24d512kw21; ../../../../config/board/twrkw24d512kw21; ../../../../../../boards/twrkw24d512kw21; ../../../../../../platform/startup/MKW21D5; ../../../../mqx/source/include; ../../../../config/common
  postbuild: "../../bat/nshell_twrkw24d512kw21.bat" "../../../.." "../../../../lib/twrkw24d512kw21.iar/debug/nshell" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; NDEBUG=1
  postbuild: "../../bat/nshell_twrkw24d512kw21.bat" "../../../.." "../../../../lib/twrkw24d512kw21.iar/release/nshell" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
