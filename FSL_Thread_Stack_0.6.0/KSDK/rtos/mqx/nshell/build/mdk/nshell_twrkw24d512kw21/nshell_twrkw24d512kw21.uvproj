# Keil uVision project nshell_twrkw24d512kw21.uvproj, settings and files
target debug (ARM-ADS)
  device: MKW21DN512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: lib_nshell.lib (library)
  AfterMake: ../../bat/nshell_twrkw24d512kw21.bat ../../../.. ../../../../lib/twrkw24d512kw21.mdk/debug/nshell mdk
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKW21D512VHA5=1, FSL_RTOS_MQX=1, _DEBUG=1
  c misc: -J../../../source/include 
-J../../../source/include 
-J../../../../mqx/source/psp/cortex_m/compiler/rv_mdk 
-J../../../../mqx/source/psp/cortex_m 
-J../../../../mqx/source/psp/cortex_m/cpu 
-J../../../../../../platform/startup 
-J../../../../../../platform/CMSIS/Include/device 
-J../../../../../../platform/CMSIS/Include 
-J../../../../config/mcu/mkw24d512kw21 
-J../../../../config/board/twrkw24d512kw21 
-J../../../../../../boards/twrkw24d512kw21 
-J../../../../../../platform/startup/MKW21D5 
-J../../../../config/common 
-J../../../../mqx/source/include 
-J../../../../mqx/source/nio 
-J../../../../mqx/source/nio/src 
-J../../../../mqx/source/nio/fs 
-J../../../../mqx/source/nio/drivers/nio_dummy 
-J../../../../mqx/source/nio/drivers/nio_mem 
-J../../../../mqx/source/nio/drivers/nio_null 
-J../../../../mqx/source/nio/drivers/nio_pipe 
-J../../../../mqx/source/nio/drivers/nio_serial 
-J../../../../mqx/source/nio/drivers/nio_tfs 
-J../../../../mqx/source/nio/drivers/nio_tty 
-J../../../../mqx/source/tad 
-J../../../../mqx/source/include 
-J../../../../mqx_stdlib/source/include 
-J../../../../mqx_stdlib/source/stdio 
-J../../../../../../platform 
-J../../../../../../platform/CMSIS/Include 
-J../../../../../../platform/CMSIS/Include/device 
-J../../../../../../platform/hal/inc 
-J../../../../../../platform/drivers/inc 
-J../../../../../../platform/drivers/src/mpu 
-J../../../../../../platform/drivers/src/uart 
-J../../../../../../platform/utilities/inc 
-J../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc 
-J../../../../.. 
-J../../../../../../platform/osa/inc 
-J../../../../../../platform/system/inc 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/include;../../../source/include;../../../../mqx/source/psp/cortex_m/compiler/rv_mdk;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/cpu;../../../../../../platform/startup;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/CMSIS/Include;../../../../config/mcu/mkw24d512kw21;../../../../config/board/twrkw24d512kw21;../../../../../../boards/twrkw24d512kw21;../../../../../../platform/startup/MKW21D5;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/nio;../../../../mqx/source/nio/src;../../../../mqx/source/nio/fs;../../../../mqx/source/nio/drivers/nio_dummy;../../../../mqx/source/nio/drivers/nio_mem;../../../../mqx/source/nio/drivers/nio_null;../../../../mqx/source/nio/drivers/nio_pipe;../../../../mqx/source/nio/drivers/nio_serial;../../../../mqx/source/nio/drivers/nio_tfs;../../../../mqx/source/nio/drivers/nio_tty;../../../../mqx/source/tad;../../../../mqx/source/include;../../../../mqx_stdlib/source/include;../../../../mqx_stdlib/source/stdio;../../../../../../platform;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/drivers/src/uart;../../../../../../platform/utilities/inc;../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc;../../../../..;../../../../../../platform/osa/inc;../../../../../../platform/system/inc
  asm misc: --cpreproc_opts '-DCPU_MKW21D512VHA5=1,-DFSL_RTOS_MQX=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../mqx/source/psp/cortex_m/compiler/rv_mdk;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/psp/cortex_m;../../../../../../platform/startup;../../../../config/mcu/mkw24d512kw21;../../../../config/board/twrkw24d512kw21;../../../../../../boards/twrkw24d512kw21;../../../../../../platform/startup/MKW21D5;../../../../mqx/source/include;../../../../config/common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\mkw24d512kw21.mdk\mqx\intflash.scf
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
target release (ARM-ADS)
  device: MKW21DN512xxx5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: lib_nshell.lib (library)
  AfterMake: ../../bat/nshell_twrkw24d512kw21.bat ../../../.. ../../../../lib/twrkw24d512kw21.mdk/release/nshell mdk
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKW21D512VHA5=1, FSL_RTOS_MQX=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DCPU_MKW21D512VHA5=1,-DFSL_RTOS_MQX=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\mkw24d512kw21.mdk\mqx\intflash.scf
