<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_stdlib_twrk21d50m</project><configuration>debug</configuration></member><member><project>nshell_twrk21d50m</project><configuration>debug</configuration></member><member><project>mqx_twrk21d50m</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>mqx_stdlib_twrk21d50m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk21d50m</project><configuration>release</configuration></member><member><project>nshell_twrk21d50m</project><configuration>debug</configuration></member><member><project>nshell_twrk21d50m</project><configuration>release</configuration></member><member><project>mqx_twrk21d50m</project><configuration>debug</configuration></member><member><project>mqx_twrk21d50m</project><configuration>release</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_stdlib_twrk21d50m</project><configuration>release</configuration></member><member><project>nshell_twrk21d50m</project><configuration>release</configuration></member><member><project>mqx_twrk21d50m</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx_stdlib\build\iar\mqx_stdlib_twrk21d50m\mqx_stdlib_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\nshell\build\iar\nshell_twrk21d50m\nshell_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\build\iar\mqx_twrk21d50m\mqx_twrk21d50m.ewp</path></project></workspace>
