<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>watchdog_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>timer_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>test_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>taskq_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>taskat_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>sem_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>nill_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>mutex_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>msg_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwsem_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwlog_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwevent_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwdemo_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>log_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>klog_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>isr_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>hello_lite_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>hello_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>event_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>demo_twrk21d50m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>watchdog_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>watchdog_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>timer_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>timer_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>test_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>test_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>taskq_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>taskq_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>taskat_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>taskat_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>sem_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>sem_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>nill_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>nill_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>mutex_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>mutex_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>msg_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>msg_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwsem_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwsem_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwmsgq_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwlog_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwlog_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwevent_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwevent_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwdemo_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>lwdemo_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>log_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>log_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>klog_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>klog_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>isr_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>isr_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>hello_lite_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>hello_lite_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>hello_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>hello_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>event_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>event_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>demo_twrk21d50m</project><configuration>int flash debug</configuration></member><member><project>demo_twrk21d50m</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>watchdog_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>timer_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>test_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>taskq_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>taskat_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>sem_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>nill_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>mutex_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>msg_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwsem_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwmsgq_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwlog_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwevent_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>lwdemo_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>log_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>klog_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>isr_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>hello_lite_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>hello_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>event_twrk21d50m</project><configuration>int flash release</configuration></member><member><project>demo_twrk21d50m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_twrk21d50m\watchdog_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_twrk21d50m\timer_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_twrk21d50m\test_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_twrk21d50m\taskq_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_twrk21d50m\taskat_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_twrk21d50m\sem_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_twrk21d50m\nill_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_twrk21d50m\mutex_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_twrk21d50m\msg_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_twrk21d50m\lwsem_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_twrk21d50m\lwmsgq_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_twrk21d50m\lwlog_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_twrk21d50m\lwevent_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo_lite\build\iar\lwdemo_lite_twrk21d50m\lwdemo_lite_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_twrk21d50m\lwdemo_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_twrk21d50m\log_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_twrk21d50m\klog_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_twrk21d50m\isr_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello_lite\build\iar\hello_lite_twrk21d50m\hello_lite_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_twrk21d50m\hello_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_twrk21d50m\event_twrk21d50m.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_twrk21d50m\demo_twrk21d50m.ewp</path></project></workspace>
