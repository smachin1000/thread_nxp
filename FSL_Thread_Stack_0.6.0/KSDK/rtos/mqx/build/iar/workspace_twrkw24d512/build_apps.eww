<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>watchdog_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>timer_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>test_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>taskq_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>taskat_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>sem_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>nill_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>mutex_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>msg_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwsem_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwlog_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwevent_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwdemo_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>log_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>klog_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>isr_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>hello_lite_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>hello_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>event_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>demo_twrkw24d512</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>watchdog_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>watchdog_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>timer_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>timer_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>test_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>test_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>taskq_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>taskq_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>taskat_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>taskat_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>sem_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>sem_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>nill_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>nill_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>mutex_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>mutex_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>msg_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>msg_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwsem_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwsem_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwmsgq_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwlog_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwlog_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwevent_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwevent_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwdemo_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>lwdemo_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>log_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>log_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>klog_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>klog_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>isr_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>isr_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>hello_lite_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>hello_lite_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>hello_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>hello_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>event_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>event_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>demo_twrkw24d512</project><configuration>int flash debug</configuration></member><member><project>demo_twrkw24d512</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>watchdog_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>timer_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>test_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>taskq_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>taskat_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>sem_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>nill_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>mutex_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>msg_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwsem_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwmsgq_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwlog_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwevent_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>lwdemo_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>log_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>klog_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>isr_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>hello_lite_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>hello_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>event_twrkw24d512</project><configuration>int flash release</configuration></member><member><project>demo_twrkw24d512</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_twrkw24d512\watchdog_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_twrkw24d512\timer_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_twrkw24d512\test_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_twrkw24d512\taskq_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_twrkw24d512\taskat_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_twrkw24d512\sem_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_twrkw24d512\nill_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_twrkw24d512\mutex_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_twrkw24d512\msg_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_twrkw24d512\lwsem_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_twrkw24d512\lwmsgq_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_twrkw24d512\lwlog_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_twrkw24d512\lwevent_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo_lite\build\iar\lwdemo_lite_twrkw24d512\lwdemo_lite_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_twrkw24d512\lwdemo_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_twrkw24d512\log_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_twrkw24d512\klog_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_twrkw24d512\isr_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello_lite\build\iar\hello_lite_twrkw24d512\hello_lite_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_twrkw24d512\hello_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_twrkw24d512\event_twrkw24d512.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_twrkw24d512\demo_twrkw24d512.ewp</path></project></workspace>
