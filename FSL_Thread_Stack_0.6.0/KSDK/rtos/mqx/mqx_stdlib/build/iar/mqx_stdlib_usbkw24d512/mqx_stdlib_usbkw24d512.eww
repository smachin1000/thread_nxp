<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_stdlib_usbkw24d512</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_stdlib_usbkw24d512</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\mqx_stdlib_usbkw24d512.ewp</path></project></workspace>
