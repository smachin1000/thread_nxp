# IAR project mqx_stdlib_twrkw24d512kw21.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/include; ../../../source/stdio; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../../../platform/startup; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/CMSIS/Include; ../../../../config/mcu/mkw24d512kw21; ../../../../config/board/twrkw24d512kw21; ../../../../../../boards/twrkw24d512kw21; ../../../../../../platform/startup/MKW21D5; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/nio; ../../../../mqx/source/nio/src; ../../../../mqx/source/nio/fs; ../../../../mqx/source/nio/drivers/nio_dummy; ../../../../mqx/source/nio/drivers/nio_mem; ../../../../mqx/source/nio/drivers/nio_null; ../../../../mqx/source/nio/drivers/nio_pipe; ../../../../mqx/source/nio/drivers/nio_serial; ../../../../mqx/source/nio/drivers/nio_tfs; ../../../../mqx/source/nio/drivers/nio_tty; ../../../../mqx/source/tad; ../../../../mqx/source/include; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/utilities/inc; ../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../..; ../../../../../../platform/osa/inc; ../../../../../../platform/system/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; _DEBUG=1
  AARM.AUserIncludes: ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m; ../../../../../../platform/startup; ../../../../config/mcu/mkw24d512kw21; ../../../../config/board/twrkw24d512kw21; ../../../../../../boards/twrkw24d512kw21; ../../../../../../platform/startup/MKW21D5; ../../../../mqx/source/include; ../../../../config/common
  postbuild: "../../bat/mqx_stdlib_twrkw24d512kw21.bat" "../../../.." "../../../../lib/twrkw24d512kw21.iar/debug/mqx_stdlib" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MKW21D512VHA5=1; FSL_RTOS_MQX=1; NDEBUG=1
  postbuild: "../../bat/mqx_stdlib_twrkw24d512kw21.bat" "../../../.." "../../../../lib/twrkw24d512kw21.iar/release/mqx_stdlib" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group mqx_stdlib Source/include
    ../../../source/include/: std_prv.h stdio.h strings.h
  group mqx_stdlib Source/mqx_stdio
    ../../../source/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fp_prv.c fp_prv.h fread.c fwrite.c get.c pos.c print.c print_prv.c print_prv.h put.c scan.c scan_prv.c scan_prv.h stdio.c
  group mqx_stdlib Source/mqx_strings
    ../../../source/strings/: strings.c
