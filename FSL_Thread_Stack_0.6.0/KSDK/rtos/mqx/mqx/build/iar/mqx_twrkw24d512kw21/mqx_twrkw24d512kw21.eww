<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_twrkw24d512kw21</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_twrkw24d512kw21</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\mqx_twrkw24d512kw21.ewp</path></project></workspace>
