# IAR project mqx_twrkw24d512.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKW24D512VHA5=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186, Pa050
  ICCARM.CCIncludePath2: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/cpu; ../../../../../../platform/startup; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/CMSIS/Include; ../../../../config/mcu/mkw24d512; ../../../../config/board/twrkw24d512; ../../../../../../boards/twrkw24d512; ../../../../../../platform/startup/MKW24D5; ../../../../config/common; ../../../source/include; ../../../source/nio; ../../../source/nio/src; ../../../source/nio/fs; ../../../source/nio/drivers/nio_dummy; ../../../source/nio/drivers/nio_mem; ../../../source/nio/drivers/nio_null; ../../../source/nio/drivers/nio_pipe; ../../../source/nio/drivers/nio_serial; ../../../source/nio/drivers/nio_tfs; ../../../source/nio/drivers/nio_tty; ../../../source/tad; ../../../source/include; ../../../../mqx_stdlib/source/include; ../../../../mqx_stdlib/source/stdio; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/utilities/inc; ../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../..; ../../../../../../platform/osa/inc; ../../../../../../platform/system/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/core/M4; ../../../source/psp/cortex_m; ../../../../../../platform/startup; ../../../../config/mcu/mkw24d512; ../../../../config/board/twrkw24d512; ../../../../../../boards/twrkw24d512; ../../../../../../platform/startup/MKW24D5; ../../../source/include; ../../../../config/common
  postbuild: "../../bat/mqx_twrkw24d512.bat" "../../../.." "../../../../lib/twrkw24d512.iar/debug/mqx" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKW24D512VHA5=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  postbuild: "../../bat/mqx_twrkw24d512.bat" "../../../.." "../../../../lib/twrkw24d512.iar/release/mqx" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group CMSIS
    ../../../../../../platform/CMSIS/Include/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../../../../../../platform/CMSIS/Include/device/: fsl_device_registers.h
  group Config Files
    ../../../../config/common/: lite_config.h maximum_config.h small_ram_config.h verif_enabled_config.h
    ../../../../config/mcu/mkw24d512/: mqx_sdk_config.h
    ../../../../config/board/twrkw24d512/: user_config.h
  group KSDK Files
    ../../../../../../platform/startup/: startup.c startup.h
    ../../../../../../platform/startup/MKW24D5/iar/: startup_MKW24D5.s
    ../../../../../../platform/startup/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group MQX Generic/include
    ../../../source/psp/cortex_m/compiler/iar/: asm_mac.h comp.c comp.h
    ../../../source/include/: charq.h eds.h eds_prv.h edserial.h edserprv.h event.h event_prv.h gen_rev.h klog.h log.h log_prv.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_macros.h mqx_prv.h mqx_str.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h queue.h sem.h sem_prv.h timer.h timer_prv.h tlsf.h tlsf_adaptation.h tlsf_adaptation_prv.h tlsfbits.h unicode.h watchdog.h watchdog_prv.h
  group MQX Generic/kernel
    ../../../source/kernel/: event.c idletask.c inittask.c int.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c timer.c tlsf.c tlsf_adaptation.c watchdog.c
    ../../../source/include/: task.h
  group MQX Generic/nio
    ../../../source/nio/src/: errno.c nio.c nio_prv.h nio_std_adpt.c
    ../../../source/nio/: errno.h fcntl.h ioctl.h nio.h
    ../../../source/nio/fs/: fs_supp.c fs_supp.h
  group MQX Generic/string
    ../../../source/string/: str_utos.c strnlen.c unicode.c
  group MQX Generic/tad
    ../../../source/tad/: tad.c tad.h
  group Peripheral NIO Drivers/nio_dummy
    ../../../source/nio/drivers/nio_dummy/src/: nio_dummy.c
    ../../../source/nio/drivers/nio_dummy/: nio_dummy.h
  group Peripheral NIO Drivers/nio_mem
    ../../../source/nio/drivers/nio_mem/src/: nio_mem.c
    ../../../source/nio/drivers/nio_mem/: nio_mem.h
  group Peripheral NIO Drivers/nio_null
    ../../../source/nio/drivers/nio_null/src/: nio_null.c
    ../../../source/nio/drivers/nio_null/: nio_null.h
  group Peripheral NIO Drivers/nio_pipe
    ../../../source/nio/drivers/nio_pipe/src/: nio_pipe.c
    ../../../source/nio/drivers/nio_pipe/: nio_pipe.h
  group Peripheral NIO Drivers/nio_serial
    ../../../source/nio/drivers/nio_serial/src/: nio_serial.c
    ../../../source/nio/drivers/nio_serial/: nio_serial.h
  group Peripheral NIO Drivers/nio_tfs
    ../../../source/nio/drivers/nio_tfs/src/: nio_tfs.c
    ../../../source/nio/drivers/nio_tfs/: nio_tfs.h
  group Peripheral NIO Drivers/nio_tty
    ../../../source/nio/drivers/nio_tty/src/: nio_tty.c
    ../../../source/nio/drivers/nio_tty/: nio_tty.h
  group PSP Cortex
    ../../../source/psp/cortex_m/core/M4/: boot.S dispatch.S psp_prv.inc support.S
    ../../../source/psp/cortex_m/: cortex.c cortex.h int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c kinetis.h kinetis_mpu.h mem_copy.c mem_zero.c nvic.c nvic.h psp.h psp_abi.h psp_comp.h psp_cpu.h psp_cpudef.h psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_math.h psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_prv.h psp_psti.c psp_rev.h psp_seti.c psp_supp.c psp_supp.h psp_tiad.c psp_tida.c psp_tihr.c psp_time.h psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c psptypes.h sc_irdyq.c stack_bu.c stack_de.c stack_st.c types.inc
    ../../../source/psp/cortex_m/cpu/: kinetis_fcan.h
