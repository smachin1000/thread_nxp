# IAR project thread_end_device_usbkw24d512.ewp, settings and files
configuration mqxlite_debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 Freescale MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MK21DN512AVMC5; IAR; FSL_RTOS_MQX; gUSBKW24D512Dongle=1; gSerialMgrUseUSB_c=1; gSerialMgrUseUart_c=0; SHELL_IO_TYPE=gSerialMgrUSB_c; gTMR_PIT_Timestamp_Enabled_d=1; gLEDsOnTargetBoardCnt_c=2; gKBD_KeysCount_c=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: ..\..\config\thread_end_device_config.h
  ICCARM.CCIncludePath2: ..\..\..\common\config\; ..\..\..\common\src\app_init\; ..\..\..\common\src\app_temp_sensor\; ..\..\..\common\src\socket_app_utils\; ..\..\src\; ..\..\..\..\..\nwk_ip\base\interface\; ..\..\..\..\..\nwk_ip\core\interface\; ..\..\..\..\..\drv\Portable\LED\Interface; ..\..\..\..\..\drv\Portable\Keyboard\Interface; ..\..\..\..\..\drv\Portable\Eeprom\Interface; ..\..\..\..\..\drv\Portable\Flash_Adapter\; ..\..\..\..\..\drv\Portable\TMR_Adapter\; ..\..\..\..\..\drv\Portable\SPI_Adapter\; ..\..\..\..\..\drv\Portable\UART_Adapter\; ..\..\..\..\..\drv\Portable\USB_VirtualCom\; ..\..\..\..\..\framework\Common; ..\..\..\..\..\framework\FSCI\Interface; ..\..\..\..\..\framework\FSCI\Source; ..\..\..\..\..\framework\LPM\Interface\KW2xD; ..\..\..\..\..\framework\LPM\Source; ..\..\..\..\..\framework\MemManager\Interface; ..\..\..\..\..\framework\Messaging\Interface; ..\..\..\..\..\framework\NVM\Interface; ..\..\..\..\..\framework\NVM\Source; ..\..\..\..\..\framework\OSAbstraction\Interface; ..\..\..\..\..\framework\OtaSupport\Interface; ..\..\..\..\..\framework\Panic\Interface; ..\..\..\..\..\framework\RNG\Interface; ..\..\..\..\..\framework\SerialManager\Interface; ..\..\..\..\..\framework\SerialManager\Source; ..\..\..\..\..\framework\Shell\Interface; ..\..\..\..\..\framework\TimersManager\Interface; ..\..\..\..\..\framework\TimersManager\Source; ..\..\..\..\..\framework\Utils\Lists; ..\..\..\..\..\framework\Utils\FunctionLib; ..\..\..\..\..\framework\Utils\SecLib; ..\..\..\..\..\framework\Utils\ModuleInfo; ..\..\..\..\..\ieee_802_15_4\Source\Phy\Interface; ..\..\..\..\..\ieee_802_15_4\Source\Phy\Source\MKW2xD\MCR20Drv; ..\..\..\..\..\ieee_802_15_4\Source\Phy\Source\XcvrSPI; ..\..\..\..\..\ieee_802_15_4\Source\Mac\Interface; ..\..\..\..\..\ieee_802_15_4\Source\App; ..\..\..\..\..\..\KSDK\rtos\mqx\lib\twrkw24d512.iar\debug\config; ..\..\..\..\..\..\KSDK\boards\twrkw24d512; ..\..\..\..\..\..\KSDK\platform\CMSIS\Include; ..\..\..\..\..\..\KSDK\platform\CMSIS\Include\device; ..\..\..\..\..\..\KSDK\platform\CMSIS\Include\device\MK21DA5; ..\..\..\..\..\..\KSDK\platform\startup\MK21DA5; ..\..\..\..\..\..\KSDK\platform\osa\inc; ..\..\..\..\..\..\KSDK\platform\drivers\src\flash\C90TFS\drvsrc\include; ..\..\..\..\..\..\KSDK\platform\drivers\inc; ..\..\..\..\..\..\KSDK\platform\hal\inc; ..\..\..\..\..\..\KSDK\platform\system\inc; ..\..\..\..\..\..\KSDK\platform\system\src\clock\MK21DA5; ..\..\..\..\..\..\KSDK\platform\utilities\inc; ..\..\..\..\..\..\KSDK\rtos\mqx\config\common; ..\..\..\..\..\..\KSDK\rtos\mqx\mqx\source\include; ..\..\..\..\..\..\KSDK\rtos\mqx\mqx\source\bsp; ..\..\..\..\..\..\KSDK\rtos\mqx\lib\twrkw24d512.iar\debug\config; ..\..\..\..\..\..\KSDK\rtos\mqx\lib\twrkw24d512.iar\debug\mqx; ..\..\..\..\..\..\KSDK\usb\adapter\sources; ..\..\..\..\..\..\KSDK\usb\adapter\sources\sdk; ..\..\..\..\..\..\KSDK\usb\usb_core\include; ..\..\..\..\..\..\KSDK\usb\usb_core\device\sources\classes\include\config\; ..\..\..\..\..\..\KSDK\usb\usb_core\device\include; ..\..\..\..\..\..\KSDK\usb\usb_core\device\include\twrkw24d512; ..\..\..\..\..\..\KSDK\usb\usb_core\device\sources\classes\include; ..\..\..\..\..\..\KSDK\usb\usb_core\device\sources\classes\cdc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: thread_end_device_usbkw24d512_debug.srec
  ILINK.IlinkOutputFile: thread_end_device_usbkw24d512_mqxlite_debug.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=5000
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\KSDK\platform\linker\MKW24D5\iar\MKW24DN512Axxx5_connectivity.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\KSDK\rtos\mqx\lib\usbkw24d512.iar\debug\mqx\lib_mqx.a; ..\..\..\..\..\..\KSDK\lib\ksdk_mqx_lib\iar\KW24D5\debug\libksdk_platform_mqx.a; ..\..\..\..\..\..\KSDK\usb\usb_core\device\build\iar\usbd_sdk_twrkw24d512_mqx\debug\libusbd_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration mqxlite (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK21DN512AVMC5; IAR; FSL_RTOS_MQX; gUSBKW24D512Dongle=1; gSerialMgrUseUSB_c=1; gSerialMgrUseUart_c=0; SHELL_IO_TYPE=gSerialMgrUSB_c; gTMR_PIT_Timestamp_Enabled_d=1; gLEDsOnTargetBoardCnt_c=2; gKBD_KeysCount_c=1
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: thread_end_device_usbkw24d512.srec
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\KSDK\rtos\mqx\lib\usbkw24d512.iar\release\mqx\lib_mqx.a; ..\..\..\..\..\..\KSDK\lib\ksdk_mqx_lib\iar\KW24D5\release\libksdk_platform_mqx.a; ..\..\..\..\..\..\KSDK\usb\usb_core\device\build\iar\usbd_sdk_twrkw24d512_mqx\release\libusbd_mqx.a
  group app/thread/common/config
    ../../../common/config/: app_config.h app_to_fwk_config.h app_to_mac_config.h app_to_stack_config.h thread_manager_config.h
  group app/thread/common/src/app_init
    ../../../common/src/app_init/: app_init.c app_init.h
  group app/thread/common/src/app_temp_sensor
    ../../../common/src/app_temp_sensor/: app_temp_sensor.c app_temp_sensor.h
  group app/thread/common/src/socket_app_utils
    ../../../common/src/socket_app_utils/: socket_app_utils.c socket_app_utils.h
  group app/thread/thread_end_device/config
    ../../config/: thread_end_device_config.h
  group app/thread/thread_end_device/src
    ../../src/: end_device_app.c end_device_app.h
  group drv/Eeprom/Interface
    ../../../../../drv/Portable/Eeprom/Interface/: Eeprom.h
  group drv/Eeprom/Source
    ../../../../../drv/Portable/Eeprom/Source/: Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group drv/Flash/Interface
    ../../../../../../KSDK/platform/drivers/src/flash/C90TFS/drvsrc/include/: SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group drv/Flash/Source
    ../../../../../../KSDK/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashInit.c FlashProgram.c FlashVerifySection.c
  group drv/Flash_Adapter
    ../../../../../drv/Portable/Flash_Adapter/: Flash_Adapter.c Flash_Adapter.h
  group drv/Keyboard/Interface
    ../../../../../drv/Portable/Keyboard/Interface/: Keyboard.h KeyboardConfig.h
  group drv/Keyboard/Source
    ../../../../../drv/Portable/Keyboard/Source/: Keyboard.c
  group drv/LED/Interface
    ../../../../../drv/Portable/LED/Interface/: LED.h LED_Config.h
  group drv/LED/Source
    ../../../../../drv/Portable/LED/Source/: LED.c
  group drv/Reset
    ../../../../../drv/Portable/Reset/: Reset.c
  group drv/SPI_Adapter
    ../../../../../drv/Portable/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group drv/TMR_Adapter
    ../../../../../drv/Portable/TMR_Adapter/: TMR_Adapter.c TMR_Adapter.h
  group drv/UART_Adapter
    ../../../../../drv/Portable/UART_Adapter/: UART_Adapter.c UART_Adapter.h
  group drv/USB_VirtualCom
    ../../../../../drv/Portable/USB_VirtualCom/: usb_descriptor.c usb_descriptor.h virtual_com.c virtual_com.h VirtualComInterface.h
  group framework/Common
    ../../../../../framework/Common/: EmbeddedTypes.h
  group framework/FSCI/Interface
    ../../../../../framework/FSCI/Interface/: FSCIConfig.h FsciInterface.h
  group framework/FSCI/Source
    ../../../../../framework/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/LPM/Interface
    ../../../../../framework/LPM/Interface/: LPMConfig.h PWR_Configuration.h PWR_Interface.h
  group framework/LPM/Source
    ../../../../../framework/LPM/Source/KW2xD/: PWR.c PWRLib.c PWRLib.h
  group framework/MemManager/Interface
    ../../../../../framework/MemManager/Interface/: MemManager.h MemManagerConfig.h
  group framework/MemManager/Source
    ../../../../../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../framework/Messaging/Source/: Messaging.c
  group framework/NVM/Interface
    ../../../../../framework/NVM/Interface/: NVM_Interface.h NVMConfig.h
  group framework/NVM/Source
    ../../../../../framework/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/OSAbstraction/Interface
    ../../../../../framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    ../../../../../framework/OSAbstraction/Source/: fsl_osa_ext_mqxlite.c
  group framework/OtaSupport/Interface
    ../../../../../framework/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../framework/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    ../../../../../framework/Panic/Interface/: Panic.h PanicConfig.h
  group framework/Panic/Source
    ../../../../../framework/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../framework/RNG/Source/: RNG.c
  group framework/SerialManager/Interface
    ../../../../../framework/SerialManager/Interface/: SerialManager.h SerialManagerConfig.h
  group framework/SerialManager/Source
    ../../../../../framework/SerialManager/Source/: SerialManager.c
  group framework/Shell/Interface
    ../../../../../framework/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    ../../../../../framework/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/TimersManager/Interface
    ../../../../../framework/TimersManager/Interface/: TimersManager.h TimersManagerConfig.h
  group framework/TimersManager/Source
    ../../../../../framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h
  group framework/Utils/FunctionLib
    ../../../../../framework/Utils/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Utils/Lists
    ../../../../../framework/Utils/Lists/: GenericList.c GenericList.h
  group framework/Utils/ModuleInfo
    ../../../../../framework/Utils/ModuleInfo/: ModuleInfo.h
  group framework/Utils/SecLib
    ../../../../../framework/Utils/SecLib/: lib_crypto_IAR_M4.a lib_mmcau.a mmcau_interface.h SecLib.c SecLib.h SecLibConfig.h
  group ieee_802_15_4
    ../../../../../ieee_802_15_4/Lib/: Freescale_802.15.4_MAC_06_M4_IAR.a
  group ieee_802_15_4/App
    ../../../../../ieee_802_15_4/Source/App/: FsciMacCommands.c FsciMacCommands.h MacGlobals.c MacGlobals.h
  group ieee_802_15_4/MAC/Interface
    ../../../../../ieee_802_15_4/Source/Mac/Interface/: MacConfig.h MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802_15_4/PHY/Interface
    ../../../../../ieee_802_15_4/Source/Phy/Interface/: AspInterface.h MpmInterface.h Phy.h PhyConfig.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802_15_4/PHY/Source/MKW2xD
    ../../../../../ieee_802_15_4/Source/Phy/Source/MKW2xD/: ASP.c MPM.c PhyDebug.c PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group ieee_802_15_4/PHY/Source/MKW2xD/MCR20
    ../../../../../ieee_802_15_4/Source/Phy/Source/MKW2xD/MCR20Drv/: MCR20Drv.c MCR20Drv.h MCR20Overwrites.h MCR20Reg.h
  group ieee_802_15_4/PHY/Source/XcvrSPI
    ../../../../../ieee_802_15_4/Source/Phy/Source/XcvrSpi/: SPI.c SPI.h
  group ksdk
    ../../../../../../KSDK/boards/usbkw24d512/: board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group ksdk/BSP Files
    ../../../../../../KSDK/rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group ksdk/Config Files
    ../../../../../../KSDK/rtos/mqx/config/mcu/mkw24d5/: mqx_sdk_config.h
    ../../../../../../KSDK/rtos/mqx/config/board/twrkw24d512/: user_config.h
  group ksdk/Config Files/Common
    ../../../../../../KSDK/rtos/mqx/config/common/: lite_config.h maximum_config.h small_ram_config.h verif_enabled_config.h
  group nwk_ip/base/fsci_cmd
    ../../../../../nwk_ip/base/fsci_cmd/: fsci_commands.c
  group nwk_ip/base/interface
    ../../../../../nwk_ip/base/interface/: debug_log.h fsci_commands.h mac_abs_802154.h mac_abs_types.h mac_filtering.h mac_filtering_cfg.h nv_data.h nvm_adapter.h shell_commands.h
  group nwk_ip/base/ip_media_if
    ../../../../../nwk_ip/base/ip_media_if/: ip_if_6LowPan.c
  group nwk_ip/base/shell_cmd
    ../../../../../nwk_ip/base/shell_cmd/: shell_commands.c
  group nwk_ip/base/stack_globals
    ../../../../../nwk_ip/base/stack_globals/: coap_globals.c dhcp_globals.c event_manager_globals.c ip_globals.c mle_globals.c mpl_globals.c nd_globals.c ripng_globals.c sixlowpan_globals.c sockets_globals.c tcp_globals.c thread_nwk_data_globals.c thread_routing_globals.c trickle_globals.c udp_globals.c
  group nwk_ip/base/thread_config
    ../../../../../nwk_ip/base/thread_config/: thread_manager_config.c
  group nwk_ip/base/utils
    ../../../../../nwk_ip/base/utils/: debug_log.c mac_abs_802154.c mac_filtering.c nv_data.c nvm_adapter.c stack_start.c
  group nwk_ip/core/interface
    ../../../../../nwk_ip/core/interface/: arp.h coap.h coap_cfg.h dhcp.h dhcp6.h dhcp6_cfg.h dhcp6_client.h dhcp6_lq_client.h dhcp6_lq_server.h dhcp6_relay_agent.h dhcp6_server.h dhcp_cfg.h dhcp_client.h dhcp_server.h dns_client.h dns_client_cfg.h dns_utils.h dtls.h dtls_config.h enet_driver.h event_manager.h event_manager_cfg.h flip_manager.h http.h http_cfg.h icmp.h icmp4.h icmp6.h icmp_cfg.h igmp.h igmp_cfg.h ip.h ip4.h ip6.h ip_cfg.h ip_if_management.h mdns.h mdns_cfg.h mle.h mle_basic.h mle_cfg.h mle_extended.h mle_security.h mle_utils.h mpl.h mpl_cfg.h nd.h nd_cfg.h nd_events.h nd_sixlowpan.h nd_tables.h network_utils.h nwk_params.h pmtu_discovery.h pmtu_discovery_cfg.h rfc4944_6lowpan.h rfc6282_header_comp.h session.h sixlowpan.h sixlowpan_cfg.h sixlowpan_fwd_thread.h sixlowpan_ib.h sixlowpan_interface.h sixlowpan_tbl.h sockets.h sockets_cfg.h ssl.h ssl_cfg.h stack_config.h stack_events.h stack_manager_if.h static_manager.h tcp.h tcp_cfg.h thread_attach.h thread_cfg.h thread_end_device.h thread_manager.h thread_network_data.h thread_router.h thread_routing.h thread_security.h thread_stack_config.h thread_state_machine.h thread_utils.h tls.h tls_cfg.h transport.h trickle.h trickle_cfg.h udp.h udp_cfg.h version.h virtual_enet_driver.h virtual_tun_driver.h
  group nwk_ip/core/lib/thread
    ../../../../../nwk_ip/core/lib/thread/: thread_m4.a
