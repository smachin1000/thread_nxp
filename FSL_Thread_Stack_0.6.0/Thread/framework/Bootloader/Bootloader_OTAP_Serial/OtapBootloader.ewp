# IAR project OtapBootloader.ewp, settings and files
configuration BootloaderOTAP_KW24D512 (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  ICCARM.CCDefines: MCU_MK21DN512; gEepromType_d=gEepromDevice_AT45DB161E_c
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: src\OtapSerialBootloader; src\eeprom; src\spi; src\flash; src\include; src\; src\include\cfg; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Binaries\BootloaderOTAP_KW24D512.srec
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_KW24D512\exe\BootloaderOTAP_KW24D512.out" "Binaries\BootloaderOTAP_KW24D512.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_KW24D512.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x80000
  ILINK.IlinkIcfFile: Linker_cfg\BootloaderOTAP.icf
  ILINK.IlinkProgramEntryLabel: main
configuration BootloaderOTAP_KW21D256 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK21DX256xxx5 Freescale MK21DX256xxx5
  ICCARM.CCDefines: MCU_MK21DX256; gEepromType_d=gEepromDevice_AT45DB161E_c
  ICCARM.CCIncludePath2: src\OtapSerialBootloader; src\eeprom; src\spi; src\flash; src\include; src\; ; src\include\cfg
  OBJCOPY.OOCOutputFile: Binaries\BootloaderOTAP_KW21D256.srec
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_KW21D256\exe\BootloaderOTAP_KW21D256.out" "Binaries\BootloaderOTAP_KW21D256.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_KW21D256.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x40000
configuration BootloaderOTAP_Serial_KW24D512 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MCU_MK21DN512; gEepromType_d=gEepromDevice_AT45DB161E_c; gSerialBootloaderEnable_c=1
  OBJCOPY.OOCOutputFile: Binaries\BootloaderOTAP_Serial_KW24D512.srec
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_Serial_KW24D512\exe\BootloaderOTAP_Serial_KW24D512.out" "Binaries\BootloaderOTAP_Serial_KW24D512.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_Serial_KW24D512.out
  group eeprom
    src/eeprom/: Eeprom_Boot.h Eeprom_Boot_AT45DB161E.c
  group flash
    src/flash/: flash_boot_kinetis.c flash_boot_kinetis.h
  group Include
    src/include/: EmbeddedTypes.h MK21D5.h MKL46Z4.h
  group Include/cfg
    src/include/cfg/: MK21D256_cfg.h MK21D512_cfg.h MK64F12_cfg.h MKL46Z256_cfg.h MKW40Z160_cfg.h
  group OtapBootloader
    src/OtapSerialBootloader/: OtapBootloader.c OtapBootloader.h UartBootloade.c UartBootloader.h
  group spi
    src/spi/: SPI.c SPI.h
